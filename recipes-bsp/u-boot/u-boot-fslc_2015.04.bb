include u-boot-fslc.inc

PV = "v2015.04+git${SRCPV}"

SRCREV = "6733bb581802ac6031b66708ddcf831b2fa16c59"
SRCBRANCH = "patches-2015.04"
